Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-07-13T19:27:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - 代替 UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 13 19:27:52 2022 * Host: 023-KYOYA-02 * Database: C:\Users\kozo-keikaku\AppData\Local\Temp\{3B6CD691-D22C-449E-B9C8-D79F0FBB981A}\ifc * Database version: 5507 * Database creation date: Wed Jul 13 19:27:46 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 13 19:27:46 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 13 19:27:46 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, レベル 1
LongName: レベル 1; Elevation: 0 mm

# IfcBuildingElementProxy: SP151, ISベース_SP:SP151:24990
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP151
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP152, ISベース_SP:SP152:36315
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP152
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP201, ISベース_SP:SP201:25139
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP201
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP202, ISベース_SP:SP202:25263
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP202
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP251 (2)
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP251
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Name (ISベース_SP:SP251:...)
25131
25147

# IfcBuildingElementProxy: SP252 (2)
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP252
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Name (ISベース_SP:SP252:...)
25262
25264

# IfcBuildingElementProxy: SP253, ISベース_SP:SP253:25285
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP253
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP254, ISベース_SP:SP254:25306
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP254
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP301, ISベース_SP:SP301:25155
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP301
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP302, ISベース_SP:SP302:32723
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP302
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP303, ISベース_SP:SP303:32748
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP303
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP304, ISベース_SP:SP304:32754
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP304
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP305, ISベース_SP:SP305:32762
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP305
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP351, ISベース_SP:SP351:25163
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP351
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP352, ISベース_SP:SP352:25266
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP352
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP353, ISベース_SP:SP353:25287
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP353
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP354, ISベース_SP:SP354:25308
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP354
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP355, ISベース_SP:SP355:25329
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP355
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP401, ISベース_SP:SP401:25173
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP401
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP402, ISベース_SP:SP402:25267
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP402
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP403, ISベース_SP:SP403:25288
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP403
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP404, ISベース_SP:SP404:25309
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP404
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP405, ISベース_SP:SP405:25330
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP405
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP406, ISベース_SP:SP406:36411
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP406
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP451, ISベース_SP:SP451:25181
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP451
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP452, ISベース_SP:SP452:25268
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP452
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP453, ISベース_SP:SP453:25289
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP453
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP454, ISベース_SP:SP454:25310
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP454
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP455, ISベース_SP:SP455:25331
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP455
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP456, ISベース_SP:SP456:25352
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP456
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP457, ISベース_SP:SP457:36439
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP457
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP501, ISベース_SP:SP501:25189
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP501
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP502, ISベース_SP:SP502:25269
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP502
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP503, ISベース_SP:SP503:25290
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP503
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP504, ISベース_SP:SP504:25311
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP504
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP505, ISベース_SP:SP505:25332
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP505
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP506, ISベース_SP:SP506:25353
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP506
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP507, ISベース_SP:SP507:36617
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP507
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP508, ISベース_SP:SP508:36623
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP508
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP551, ISベース_SP:SP551:25197
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP551
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP552, ISベース_SP:SP552:25270
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP552
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP553, ISベース_SP:SP553:25291
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP553
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP554, ISベース_SP:SP554:25312
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP554
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP555, ISベース_SP:SP555:25333
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP555
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP556, ISベース_SP:SP556:25354
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP556
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP557, ISベース_SP:SP557:36656
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP557
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP601, ISベース_SP:SP601:25205
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP601
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP602, ISベース_SP:SP602:25271
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP602
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP603, ISベース_SP:SP603:25292
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP603
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP604, ISベース_SP:SP604:25313
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP604
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP605, ISベース_SP:SP605:25334
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP605
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP606, ISベース_SP:SP606:25355
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP606
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP651, ISベース_SP:SP651:25215
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP651
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP652, ISベース_SP:SP652:25272
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP652
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP653, ISベース_SP:SP653:25293
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP653
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP654, ISベース_SP:SP654:25314
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP654
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP655, ISベース_SP:SP655:25335
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP655
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP656, ISベース_SP:SP656:36698
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP656
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP701, ISベース_SP:SP701:25223
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP701
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP702, ISベース_SP:SP702:25273
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP702
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP703, ISベース_SP:SP703:25294
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP703
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP704, ISベース_SP:SP704:25315
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP704
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP751, ISベース_SP:SP751:25231
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP751
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP752, ISベース_SP:SP752:25274
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP752
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP753, ISベース_SP:SP753:25295
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP753
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP754, ISベース_SP:SP754:25316
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP754
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP801, ISベース_SP:SP801:33011
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP801
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP802, ISベース_SP:SP802:33012
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP802
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP803, ISベース_SP:SP803:33013
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP803
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SP804, ISベース_SP:SP804:33014
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SP804
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
